## Kconfig
```kconfig
# Copyright 2024 NXP
# SPDX-License-Identifier: BSD-3-Clause

config MCUX_COMPONENT_middleware.lin_stack
    bool "LIN stack"
    select MCUX_COMPONENT_driver.lin_lpuart
```
